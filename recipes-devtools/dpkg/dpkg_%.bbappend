# FreeBSD targets do not use the glibc ldconfig package.
EXTRA_RDPENDS:class-target:libc-freebsd = ""
