ALTERNATIVE:${PN}:append:class-target:freebsd = " lesskey"
